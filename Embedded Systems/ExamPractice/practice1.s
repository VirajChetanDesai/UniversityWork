	AREA Reset,DATA,READONLY ;SELECTION SORT
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=IN
	MOV R9,R0
	LDR R1,=OUT
LOOP LDR R2,[R0],#4
	STR R2,[R1],#4
	CMP R2,R9
	BNE LOOP
	BEQ EXIT1
	
EXIT1 LDR R0,=OUT
	
INIT	MOV R2,R0 ;INNER LOOP
	LDR R11,[R0]
	CMP R11,R9
	BEQ STOP
	MOV R5,#255
LOOP2 LDR R4,[R2]
	CMP R4,R9
	BEQ CHANGE
	CMP R4,R5
	BLT UPDATE
	ADD R2,#4
RET	B LOOP2

UPDATE MOV R5,R4
	MOV R6,R4 ;STORE VALUE
	MOV R7,R2 ;STORES ADDRESS
	ADD  R2,R2,#4
	B LOOP2

CHANGE LDR R8,[R0]
	STR R6,[R0],#4
	STR R8,[R7]
	B INIT

STOP B STOP
IN DCD 2,4,1,3,5,6,7,6
	AREA data,DATA,READWRITE
OUT DCD 0
	END