	AREA Reset,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	EXPORT Reset_Handler
Reset_Handler
	LDR R10,=NUM1 ; PERMENANT ADDRESS FOR FIRST 
	LDR R0,=NUM1 ; POINTING TO ORIGNINAL STORAGE
	LDR R1,=DEST ; POINTING TO DESTINATION ADDRESS
LOOP LDR R2,[R0],#4
	CMP R2,R10
	BEQ EXIT1
	STR R2,[R1],#4
	B LOOP
EXIT1 LDR R0,=DEST ;DEVIATING POINTER
	LDR R1,=DEST ; OUTER POINTER
	MOV R3,#255
	B LOOP2
UPDATE 
	CMP R4,#0
	BEQ EXIT2
	MOV R3,R4
	MOV R5,R0
	B RET
LOOP2 LDR R4,[R0]
	CMP R4,R3
	BLO UPDATE
RET	ADD R0,R0,#4
	B LOOP2;CODE TO FIND THE MINIMUM
EXIT2 
	CMP R3,#255
	BEQ STOP
	LDR R6,[R1]
	STR R3,[R1];SWAPPING
	STR R6,[R5]
	ADD R1,R1,#4
	MOV R0,R1
	MOV R3,#255
	B LOOP2
STOP B STOP
NUM1 DCD 1,5,7,6,3,4
	AREA data,DATA,READWRITE
DEST DCD 0
	END